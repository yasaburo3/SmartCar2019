# Keil uVision project SmartCar.uvprojx, settings and files
target SmartCar (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: SKEAZ128xxx4 NXP
  pack: Keil.Kinetis_KEAxx_DFP.1.3.0
  cpu: IROM(0x00000000,0x00020000) IRAM(0x1FFFF000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SmartCar +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: ..\..\Libraries\Startup\CoreSupport;..\..\Libraries\Startup\DeviceSupport;..\..\Libraries\Drivers\Inc;.\User\Inc;..\..\Libraries\Devices\Inc
  asm include: ..\..\Libraries\Startup\CoreSupport;..\..\Libraries\Startup\DeviceSupport;..\..\Libraries\Drivers\Inc;.\User\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Startup
    ../../Libraries/Startup/DeviceSupport/MDK-ARM/: startup_SKEAZ1284.s
    ../../Libraries/Startup/DeviceSupport/: system_SKEAZ1284.c
  group Drivers
    ../../Libraries/Drivers/Src/: adc.c ftm.c i2c.c ics.c pit.c common.c spi.c KEA128_irq.c uart.c
  group User
    ./User/Src/: control.c init.c main.c signal.c mpu6050.c delay.c
  group New Group
    ../../Libraries/Devices/Src/: lcd.c oled.c
